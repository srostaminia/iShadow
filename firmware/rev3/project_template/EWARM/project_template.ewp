# IAR project project_template.ewp, settings and files
configuration project_template (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xD ST STM32L152xD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32L152xD; USE_HAL_DRIVER; USE_STM32L152D_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\lib\STM32Cube_FW_L1_V1.3.0\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\lib\STM32Cube_FW_L1_V1.3.0\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\..\lib\STM32Cube_FW_L1_V1.3.0\Drivers\BSP\STM32L152D_EVAL; ..\..\..\lib\STM32Cube_FW_L1_V1.3.0\Drivers\BSP\Components\Common; ..\..\..\lib\STM32Cube_FW_L1_V1.3.0\Utilities\Log; ..\..\..\lib\STM32Cube_FW_L1_V1.3.0\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project_template.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l152xd_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../lib/STM32Cube_FW_L1_V1.3.0/Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../../../lib/STM32Cube_FW_L1_V1.3.0/Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../lib/STM32Cube_FW_L1_V1.3.0/Drivers/BSP/Components/ili9320/: ili9320.c
    ../../../lib/STM32Cube_FW_L1_V1.3.0/Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../lib/STM32Cube_FW_L1_V1.3.0/Drivers/BSP/Components/spfd5408/: spfd5408.c
    ../../../lib/STM32Cube_FW_L1_V1.3.0/Drivers/BSP/Components/stlm75/: stlm75.c
  group Drivers/BSP/STM32L152D_EVAL
    ../../../lib/STM32Cube_FW_L1_V1.3.0/Drivers/BSP/STM32L152D_EVAL/: stm32l152d_eval.c stm32l152d_eval_audio.c stm32l152d_eval_eeprom.c stm32l152d_eval_glass_lcd.c stm32l152d_eval_lcd.c stm32l152d_eval_nor.c stm32l152d_eval_sd.c stm32l152d_eval_sram.c stm32l152d_eval_tsensor.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver/Essential
    ../../../lib/STM32Cube_FW_L1_V1.3.0/Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c
  group Drivers/STM32L1xx_HAL_Driver/Optional
    ../../../lib/STM32Cube_FW_L1_V1.3.0/Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c stm32l1xx_ll_fsmc.c stm32l1xx_ll_sdmmc.c
  group Example/EWARM
    ./: startup_stm32l152xd.s
  group Example/User
    ../Src/: main.c stm32l1xx_hal_msp.c stm32l1xx_it.c
