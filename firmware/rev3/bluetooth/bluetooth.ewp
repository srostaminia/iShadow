# IAR project bluetooth.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151RD ST STM32L151RD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L1XX_HD; USE_STM32L151XD
  ICCARM.CCIncludePath2: ..\..\lib\CMSIS\Device\ST\STM32L1xx\Include\; ..\..\lib\STM32L1xx_StdPeriph_Driver\inc; $PROJ_DIR$; ..\..\lib\CMSIS\Include; Startup Files\Flash; ..\..\lib\STM32_USB-FS-Device_Driver\inc; inc; ..\..\lib\SDIO_Driver; ..\..\lib\stonyman
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AExtraOptionsV2: -mcpu=cortex-m3; -mthumb
  OBJCOPY.OOCOutputFile: bluetooth.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../../../../../../../Dropbox/Research/C - bluetooth/: binaryToBuffer.c img.png text.txt
    ./: main.c
    ../../lib/SDIO_Driver/: stm32l152d_eval.c
  group SPL Config
    ../../lib/CMSIS/Include/: core_cm3.h
    Startup Files/Flash/: startup_stm32l1xx_hd.s
    ../../lib/CMSIS/Device/ST/STM32L1xx/Include/: stm32l1xx.h system_stm32l1xx.h
    ./: stm32l1xx_conf.h stm32l1xx_it.c stm32l1xx_it.h system_stm32l1xx.c
  group SPL Source
    ../../lib/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
