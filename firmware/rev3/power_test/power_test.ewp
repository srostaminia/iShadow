# IAR project power_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151xD ST STM32L151xD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32L1XX_HD
  ICCARM.CCIncludePath2: ..\..\common_libs\CMSIS\Device\ST\STM32L1xx\Include\; ..\..\common_libs\STM32L1xx_StdPeriph_Driver\inc; $PROJ_DIR$; ..\..\common_libs\CMSIS\Include; \..\..\common_libs\SDIO_Driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AExtraOptionsV2: -mcpu=cortex-m3; -mthumb
  OBJCOPY.OOCOutputFile: power_test.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    $EW_DIR$/arm/inc/ST/: iostm32L151xx.h
    ./: main.c main.h TestSDCard.c
    ../isoch_camera/: predict_gaze.c predict_gaze.h
  group Filesystem
    ../../common_libs/SDIO_Driver/: diskio.c lowlevel.c stm32l152d_eval_sdio_sd.c
  group SPL Config
    Startup Files/Flash/: startup_stm32l1xx_hd.s
    CMSIS/Device/ST/STM32L1xx/Include/: stm32l1xx.h system_stm32l1xx.h
    ./: stm32l1xx_conf.h stm32l1xx_it.c stm32l1xx_it.h system_stm32l1xx.c
  group SPL Source
    ../../common_libs/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group Stonyman
    ./: libstony.c libstony.h
