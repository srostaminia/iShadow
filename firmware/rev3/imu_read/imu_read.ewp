# IAR project imu_read.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151xD ST STM32L151xD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32L1XX_HD; MPU9150
  ICCARM.CCIncludePath2: ..\..\common_libs\CMSIS\Device\ST\STM32L1xx\Include\; ..\..\common_libs\STM32L1xx_StdPeriph_Driver\inc; $PROJ_DIR$; ..\..\common_libs\CMSIS\Include; ..\..\common_libs\STM32_CPAL_Driver\inc; ..\..\common_libs\STM32_CPAL_Driver\devices\stm32l1xx; ..\..\common_libs\MPU9150\inc; ..\..\common_libs\eMPL
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AExtraOptionsV2: -mcpu=cortex-m3; -mthumb
  OBJCOPY.OOCOutputFile: imu_read.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    $EW_DIR$/arm/inc/ST/: iostm32L151xx.h
    ./: main.c main.h mpu9150_interrupts.c
  group CPAL Source
    ../../common_libs/STM32_CPAL_Driver/src/: cpal_hal.c cpal_i2c.c cpal_usercallback.c
    ../../common_libs/STM32_CPAL_Driver/devices/stm32l1xx/: cpal_i2c_hal_stm32l1xx.c
  group eMPL
    ../../common_libs/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group MPU9150
    ../../common_libs/MPU9150/src/: stm32_CPAL_mpu9150.c utils.c
  group SPL Config
    ../../common_libs/CMSIS/Include/: core_cm3.h
    Startup Files/Flash/: startup_stm32l1xx_hd.s
    ../../common_libs/CMSIS/Device/ST/STM32L1xx/Include/: stm32l1xx.h system_stm32l1xx.h
    ./: stm32l1xx_conf.h stm32l1xx_it.c stm32l1xx_it.h system_stm32l1xx.c
  group SPL Source
    ../../common_libs/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
