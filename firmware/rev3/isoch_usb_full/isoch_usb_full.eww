<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\isoch_usb_full.ewp</path>
  </project>
  <batchBuild/>
</workspace>


