# IAR project isoch_camera.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151xD ST STM32L151xD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32L1XX_HD; USE_STM32L151XD
  ICCARM.CCIncludePath2: ..\..\lib\CMSIS\Device\ST\STM32L1xx\Include\; ..\..\lib\STM32L1xx_StdPeriph_Driver\inc; $PROJ_DIR$; ..\..\lib\CMSIS\Include; Startup Files\Flash; ..\..\lib\STM32_USB-FS-Device_Driver\inc; inc; ..\..\lib\SDIO_Driver; ..\..\lib\stonyman; \\vmware-host\Shared Folders\Desktop\stonyman
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AExtraOptionsV2: -mcpu=cortex-m3; -mthumb
  OBJCOPY.OOCOutputFile: isoch_camera.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    $EW_DIR$/arm/inc/ST/: iostm32L151xx.h
    ./: main.c main.h
  group SDIO Driver
    ../../lib/SDIO_Driver/: diskio.c lowlevel.c stm32l152d_eval_sdio_sd.c
  group SPL Config
    ../../lib/CMSIS/Include/: core_cm3.h
    Startup Files/Flash/: startup_stm32l1xx_hd.s
    ../../lib/CMSIS/Device/ST/STM32L1xx/Include/: stm32l1xx.h system_stm32l1xx.h
    ./: stm32l1xx_conf.h stm32l1xx_it.c stm32l1xx_it.h system_stm32l1xx.c
  group SPL Source
    ../../lib/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group STM32_USB-FS-Device_Driver
    ../../lib/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Stonyman
    ../../lib/stonyman/: eye_models.c eye_models.h stonyman.c stonyman.h
    ./: stonyman_conf.h
  group USB
    src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
